# Keil uVision project blink_nrf.uvprojx, settings and files
target Release_nRF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: blink_nrf +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group Source Comun
    ../../src/: main.c app_guitar_hero_FSM.c app_guitar_hero_FSM.h drv_botones.c drv_botones.h drv_consumo.c drv_consumo.h drv_leds.c drv_leds.h drv_monitor.c drv_monitor.h drv_sc.c drv_sc.h drv_tiempo.c drv_tiempo.h drv_uart.c drv_uart.h drv_wdt.c drv_wdt.h svc_alarma.c svc_alarma.h svc_estadisticas.c svc_estadisticas.h svc_GE.h random.h rt_evento_t.h rt_fifo.c rt_fifo.h rt_GE.c rt_GE.h hal_consumo.h hal_ext_int.h hal_gpio.h hal_tiempo.h hal_sc.h hal_uart.h hal_wdt.h app_bit_counter_strike.h app_guitar_hero.h app_bit_counter_strike.c app_guitar_hero.c
  group Dependientes
    ../../src/: board.h
    ../src_nrf/: hal_consumo_nrf.c hal_ext_int_nrf.c hal_gpio_nrf.c hal_random_nrf.c hal_sc_nrf.c hal_tiempo_nrf.c hal_uart_nrf.c hal_wdt_nrf.c board_nrf52840dk.h board_nrf52840_dongle.h
target Debug_nRF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192 DEBUG
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
software components: CMSIS:CORE 5.3.0, Device:Startup 8.44.1
