# Keil uVision project blink_lpc.uvproj, settings and files
target Release_LPC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: blink_lpc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Comun
    ../../src/: main.c drv_leds.c drv_leds.h drv_tiempo.c drv_tiempo.h hal_gpio.h hal_tiempo.h board.h hal_consumo.h drv_consumo.h drv_consumo.c drv_monitor.c drv_monitor.h rt_evento_t.h rt_fifo.c rt_fifo.h drv_botones.c rt_GE.c svc_alarma.c drv_botones.h hal_ext_int.h rt_GE.h svc_alarma.h svc_GE.h bit_counter_strike.c drv_sc.c drv_wdt.c bit_counter_strike.h drv_sc.h drv_wdt.h hal_sc.h hal_wdt.h guitar_hero.c guitar_hero.h drv_uart.c drv_uart.h hal_uart.h
  group Dependientes
    ../src_lpc/: board_lpc.h hal_gpio_lpc.c hal_tiempo_lpc.c reserva_gpio_lpc2105.h hal_consumo_lpc.c hal_ext_int_lpc.c hal_sc_lpc.c hal_wdt_lpc.c hal_random_lpc.c hal_uart_lpc.c
  group Inicio
    ../src_lpc/: Startup.s
target Debug_LPC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: as above
  output: blink_lpc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LPC2105_simulador, DEBUG
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
